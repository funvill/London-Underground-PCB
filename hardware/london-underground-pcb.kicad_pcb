# Repository funvill/London-Underground-PCB

File README.md:

# London-Underground-PCB

A decorative PCB with 600 individually addressable RGB LEDs arranged in the London Underground map layout. Animated trains travel along each tube line using official TfL line colors.

[PCB Preview](https://kicanvas.org/?github=https://github.com/funvill/London-Underground-PCB/tree/main/hardware) via kicanvas

## Documentation

- [docs.md](docs.md) — Full project documentation (hardware specs, firmware guide, station mapping)
- [CHANGELOG.md](CHANGELOG.md) — Version history for firmware and hardware
- [CLAUDE.md](CLAUDE.md) — Guide for AI assistants making changes to this project

## Versions

- **Hardware:** v2025-Nov-30
- **Firmware:** v1.0.0

## Related

See [Washington Metro PCB](https://github.com/funvill/washington-metro-pcb) for a previous example.

Made by: [Steven (@funvill)](https://blog.abluestar.com/about)

## KiCad design hardware/london-underground-pcb.kicad_pcb

Schematic: london-underground-pcb.kicad_sch

Parts:
+5V1, +5V2, +5V3, +5V4, +5V5, +5V6, +5V7, +5V8: TestPoint; TestPoint_Pad_3.0x3.0mm
GND1: TestPoint; TestPoint_Pad_3.0x3.0mm
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_DIN965_Pad
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED20, LED21, LED22, LED23, LED24, LED25, LED26, LED27, LED28, LED29, LED30, LED31, LED32, LED33, LED34, LED35, LED36, LED37, LED38, LED39, LED40, LED41, LED42, LED43, LED44, LED45, LED46, LED47, LED48, LED49, LED50, LED51, LED52, LED53, LED54, LED55, LED56, LED57, LED58, LED59, LED60, LED61, LED62, LED63, LED64, LED65, LED66, LED67, LED68, LED69, LED70, LED71, LED72, LED73, LED74, LED75, LED76, LED77, LED78, LED79, LED80, LED81, LED82, LED83, LED84, LED85, LED86, LED87, LED88, LED89, LED90, LED91, LED92, LED93, LED94, LED95, LED96, LED97, LED98, LED99, LED100, LED101, LED102, LED103, LED104, LED105, LED106, LED107, LED108, LED109, LED110, LED111, LED112, LED113, LED114, LED115, LED116, LED117, LED118, LED119, LED120, LED121, LED122, LED123, LED124, LED125, LED126, LED127, LED128, LED129, LED130, LED131, LED132, LED133, LED134, LED135, LED136, LED137, LED138, LED139, LED140, LED141, LED142, LED143, LED144, LED145, LED146, LED147, LED148, LED149, LED150, LED151, LED152, LED153, LED154, LED155, LED156, LED157, LED158, LED159, LED160, LED161, LED162, LED163, LED164, LED165, LED166, LED167, LED168, LED169, LED170, LED171, LED172, LED173, LED174, LED175, LED176, LED177, LED178, LED179, LED180, LED181, LED182, LED183, LED184, LED185, LED186, LED187, LED188, LED189, LED190, LED191, LED192, LED193, LED194, LED195, LED196, LED197, LED198, LED199, LED200, LED201, LED202, LED203, LED204, LED205, LED206, LED207, LED208, LED209, LED210, LED211, LED212, LED213, LED214, LED215, LED216, LED217, LED218, LED219, LED220, LED221, LED222, LED223, LED224, LED225, LED226, LED227, LED228, LED229, LED230, LED231, LED232, LED233, LED234, LED235, LED236, LED237, LED238, LED239, LED240, LED241, LED242, LED243, LED244, LED245, LED246, LED247, LED248, LED249, LED250, LED251, LED252, LED253, LED254, LED255, LED256, LED257, LED258, LED259, LED260, LED261, LED262, LED263, LED264, LED265, LED266, LED267, LED268, LED269, LED270, LED271, LED272, LED273, LED274, LED275, LED276, LED277, LED278, LED279, LED280, LED281, LED282, LED283, LED284, LED285, LED286, LED287, LED288, LED289, LED290, LED291, LED292, LED293, LED294, LED295, LED296, LED297, LED298, LED299, LED300, LED301, LED302, LED303, LED304, LED305, LED306, LED307, LED308, LED309, LED310, LED311, LED312, LED313, LED314, LED315, LED316, LED317, LED318, LED319, LED320, LED321, LED322, LED323, LED324, LED325, LED326, LED327, LED328, LED329, LED330, LED331, LED332, LED333, LED334, LED335, LED336, LED337, LED338, LED339, LED340, LED341, LED342, LED343, LED344, LED345, LED346, LED347, LED348, LED349, LED350, LED351, LED352, LED353, LED354, LED355, LED356, LED357, LED358, LED359, LED360, LED361, LED362, LED363, LED364, LED365, LED366, LED367, LED368, LED369, LED370, LED371, LED372, LED373, LED374, LED375, LED376, LED377, LED378, LED379, LED380, LED381, LED382, LED383, LED384, LED385, LED386, LED387, LED388, LED389, LED390, LED391, LED392, LED393, LED394, LED395, LED396, LED397, LED398, LED399, LED400, LED401, LED402, LED403, LED404, LED405, LED406, LED407, LED408, LED409, LED410, LED411, LED412, LED413, LED414, LED415, LED416, LED417, LED418, LED419, LED420, LED421, LED422, LED423, LED424, LED425, LED426, LED427, LED428, LED429, LED430, LED431, LED432, LED433, LED434, LED435, LED436, LED437, LED438, LED439, LED440, LED441, LED442, LED443, LED444, LED445, LED446, LED447, LED448, LED449, LED450, LED451, LED452, LED453, LED454, LED455, LED456, LED457, LED458, LED459, LED460, LED461, LED462, LED463, LED464, LED465, LED466, LED467, LED468, LED469, LED470, LED471, LED472, LED473, LED474, LED475, LED476, LED477, LED478, LED479, LED480, LED481, LED482, LED483, LED484, LED485, LED486, LED487, LED488, LED489, LED490, LED491, LED492, LED493, LED494, LED495, LED496, LED497, LED498, LED499, LED500, LED501, LED502, LED503, LED504, LED505, LED506, LED507, LED508, LED509, LED510, LED511, LED512, LED513, LED514, LED515, LED516, LED517, LED518, LED519, LED520, LED521, LED522, LED523, LED524, LED525, LED526, LED527, LED528, LED529, LED530, LED531, LED532, LED533, LED534, LED535, LED536, LED537, LED538, LED539, LED540, LED541, LED542, LED543, LED544, LED545, LED546, LED547, LED548, LED549, LED550, LED551, LED552, LED553, LED554, LED555, LED556, LED557, LED558, LED559, LED560, LED561, LED562, LED563, LED564, LED565, LED566, LED567, LED568, LED569: XL-1615RGBC-WS2812B; LED-SMD_4P-L1.6-W1.5_XL-1615RGBC-WS2812B-1; LCSC Part C5349954
LED_IN1: TestPoint; TestPoint_Pad_3.0x3.0mm
LED_OUT1: TestPoint; TestPoint_Pad_3.0x3.0mm
R1, R2, R3, R4, R5, R6: 1206W4F0000T5E; R_1206_3216Metric; LCSC Part C17888
ROW1, ROW2, ROW3, ROW4, ROW5, ROW6, ROW7, ROW8, ROW9, ROW10, ROW11, ROW12, ROW13, ROW14, ROW15, ROW16, ROW17, ROW18, ROW19, ROW20, ROW21, ROW22, ROW23, ROW24, ROW25, ROW26, ROW27, ROW28, ROW29, ROW30, ROW31, ROW32, ROW33, ROW34, ROW35, ROW36, ROW37, ROW38, ROW39, ROW40, ROW41, ROW42, ROW43, ROW44, ROW45, ROW46, ROW47, ROW48, ROW49, ROW50, ROW51, ROW52, ROW53, ROW54, ROW55, ROW56, ROW57, ROW58, ROW59, ROW60: 10uF,10V,X5R; C_0402_1005Metric; MFGPN CL05A105KA5NQNC; LCSC C52923
SW1, SW2, SW3, SW4: TS-1187A-B-A-B; SW-SMD_4P-L5.1-W5.1-P3.70-LS6.5-TL_H1.5; LCSC Part C318884; not fitted
U1: XIAO-RP2040-DIP; XIAO-RP2040-SMD; not fitted

Connections:
+5V: +5V1.1, +5V2.1, +5V3.1, +5V4.1, +5V5.1, +5V6.1, +5V7.1, +5V8.1, LED1.3 (VDD), LED2.3 (VDD), LED3.3 (VDD), LED4.3 (VDD), LED5.3 (VDD), LED6.3 (VDD), LED7.3 (VDD), LED8.3 (VDD), LED9.3 (VDD), LED10.3 (VDD), LED11.3 (VDD), LED12.3 (VDD), LED13.3 (VDD), LED14.3 (VDD), LED15.3 (VDD), LED16.3 (VDD), LED17.3 (VDD), LED18.3 (VDD), LED19.3 (VDD), LED20.3 (VDD), LED21.3 (VDD), LED22.3 (VDD), LED23.3 (VDD), LED24.3 (VDD), LED25.3 (VDD), LED26.3 (VDD), LED27.3 (VDD), LED28.3 (VDD), LED29.3 (VDD), LED30.3 (VDD), LED31.3 (VDD), LED32.3 (VDD), LED33.3 (VDD), LED34.3 (VDD), LED35.3 (VDD), LED36.3 (VDD), LED37.3 (VDD), LED38.3 (VDD), LED39.3 (VDD), LED40.3 (VDD), LED41.3 (VDD), LED42.3 (VDD), LED43.3 (VDD), LED44.3 (VDD), LED45.3 (VDD), LED46.3 (VDD), LED47.3 (VDD), LED48.3 (VDD), LED49.3 (VDD), LED50.3 (VDD), LED51.3 (VDD), LED52.3 (VDD), LED53.3 (VDD), LED54.3 (VDD), LED55.3 (VDD), LED56.3 (VDD), LED57.3 (VDD), LED58.3 (VDD), LED59.3 (VDD), LED60.3 (VDD), LED61.3 (VDD), LED62.3 (VDD), LED63.3 (VDD), LED64.3 (VDD), LED65.3 (VDD), LED66.3 (VDD), LED67.3 (VDD), LED68.3 (VDD), LED69.3 (VDD), LED70.3 (VDD), LED71.3 (VDD), LED72.3 (VDD), LED73.3 (VDD), LED74.3 (VDD), LED75.3 (VDD), LED76.3 (VDD), LED77.3 (VDD), LED78.3 (VDD), LED79.3 (VDD), LED80.3 (VDD), LED81.3 (VDD), LED82.3 (VDD), LED83.3 (VDD), LED84.3 (VDD), LED85.3 (VDD), LED86.3 (VDD), LED87.3 (VDD), LED88.3 (VDD), LED89.3 (VDD), LED90.3 (VDD), LED91.3 (VDD), LED92.3 (VDD), LED93.3 (VDD), LED94.3 (VDD), LED95.3 (VDD), LED96.3 (VDD), LED97.3 (VDD), LED98.3 (VDD), LED99.3 (VDD), LED100.3 (VDD), LED101.3 (VDD), LED102.3 (VDD), LED103.3 (VDD), LED104.3 (VDD), LED105.3 (VDD), LED106.3 (VDD), LED107.3 (VDD), LED108.3 (VDD), LED109.3 (VDD), LED110.3 (VDD), LED111.3 (VDD), LED112.3 (VDD), LED113.3 (VDD), LED114.3 (VDD), LED115.3 (VDD), LED116.3 (VDD), LED117.3 (VDD), LED118.3 (VDD), LED119.3 (VDD), LED120.3 (VDD), LED121.3 (VDD), LED122.3 (VDD), LED123.3 (VDD), LED124.3 (VDD), LED125.3 (VDD), LED126.3 (VDD), LED127.3 (VDD), LED128.3 (VDD), LED129.3 (VDD), LED130.3 (VDD), LED131.3 (VDD), LED132.3 (VDD), LED133.3 (VDD), LED134.3 (VDD), LED135.3 (VDD), LED136.3 (VDD), LED137.3 (VDD), LED138.3 (VDD), LED139.3 (VDD), LED140.3 (VDD), LED141.3 (VDD), LED142.3 (VDD), LED143.3 (VDD), LED144.3 (VDD), LED145.3 (VDD), LED146.3 (VDD), LED147.3 (VDD), LED148.3 (VDD), LED149.3 (VDD), LED150.3 (VDD), LED151.3 (VDD), LED152.3 (VDD), LED153.3 (VDD), LED154.3 (VDD), LED155.3 (VDD), LED156.3 (VDD), LED157.3 (VDD), LED158.3 (VDD), LED159.3 (VDD), LED160.3 (VDD), LED161.3 (VDD), LED162.3 (VDD), LED163.3 (VDD), LED164.3 (VDD), LED165.3 (VDD), LED166.3 (VDD), LED167.3 (VDD), LED168.3 (VDD), LED169.3 (VDD), LED170.3 (VDD), LED171.3 (VDD), LED172.3 (VDD), LED173.3 (VDD), LED174.3 (VDD), LED175.3 (VDD), LED176.3 (VDD), LED177.3 (VDD), LED178.3 (VDD), LED179.3 (VDD), LED180.3 (VDD), LED181.3 (VDD), LED182.3 (VDD), LED183.3 (VDD), LED184.3 (VDD), LED185.3 (VDD), LED186.3 (VDD), LED187.3 (VDD), LED188.3 (VDD), LED189.3 (VDD), LED190.3 (VDD), LED191.3 (VDD), LED192.3 (VDD), LED193.3 (VDD), LED194.3 (VDD), LED195.3 (VDD), LED196.3 (VDD), LED197.3 (VDD), LED198.3 (VDD), LED199.3 (VDD), LED200.3 (VDD), LED201.3 (VDD), LED202.3 (VDD), LED203.3 (VDD), LED204.3 (VDD), LED205.3 (VDD), LED206.3 (VDD), LED207.3 (VDD), LED208.3 (VDD), LED209.3 (VDD), LED210.3 (VDD), LED211.3 (VDD), LED212.3 (VDD), LED213.3 (VDD), LED214.3 (VDD), LED215.3 (VDD), LED216.3 (VDD), LED217.3 (VDD), LED218.3 (VDD), LED219.3 (VDD), LED220.3 (VDD), LED221.3 (VDD), LED222.3 (VDD), LED223.3 (VDD), LED224.3 (VDD), LED225.3 (VDD), LED226.3 (VDD), LED227.3 (VDD), LED228.3 (VDD), LED229.3 (VDD), LED230.3 (VDD), LED231.3 (VDD), LED232.3 (VDD), LED233.3 (VDD), LED234.3 (VDD), LED235.3 (VDD), LED236.3 (VDD), LED237.3 (VDD), LED238.3 (VDD), LED239.3 (VDD), LED240.3 (VDD), LED241.3 (VDD), LED242.3 (VDD), LED243.3 (VDD), LED244.3 (VDD), LED245.3 (VDD), LED246.3 (VDD), LED247.3 (VDD), LED248.3 (VDD), LED249.3 (VDD), LED250.3 (VDD), LED251.3 (VDD), LED252.3 (VDD), LED253.3 (VDD), LED254.3 (VDD), LED255.3 (VDD), LED256.3 (VDD), LED257.3 (VDD), LED258.3 (VDD), LED259.3 (VDD), LED260.3 (VDD), LED261.3 (VDD), LED262.3 (VDD), LED263.3 (VDD), LED264.3 (VDD), LED265.3 (VDD), LED266.3 (VDD), LED267.3 (VDD), LED268.3 (VDD), LED269.3 (VDD), LED270.3 (VDD), LED271.3 (VDD), LED272.3 (VDD), LED273.3 (VDD), LED274.3 (VDD), LED275.3 (VDD), LED276.3 (VDD), LED277.3 (VDD), LED278.3 (VDD), LED279.3 (VDD), LED280.3 (VDD), LED281.3 (VDD), LED282.3 (VDD), LED283.3 (VDD), LED284.3 (VDD), LED285.3 (VDD), LED286.3 (VDD), LED287.3 (VDD), LED288.3 (VDD), LED289.3 (VDD), LED290.3 (VDD), LED291.3 (VDD), LED292.3 (VDD), LED293.3 (VDD), LED294.3 (VDD), LED295.3 (VDD), LED296.3 (VDD), LED297.3 (VDD), LED298.3 (VDD), LED299.3 (VDD), LED300.3 (VDD), LED301.3 (VDD), LED302.3 (VDD), LED303.3 (VDD), LED304.3 (VDD), LED305.3 (VDD), LED306.3 (VDD), LED307.3 (VDD), LED308.3 (VDD), LED309.3 (VDD), LED310.3 (VDD), LED311.3 (VDD), LED312.3 (VDD), LED313.3 (VDD), LED314.3 (VDD), LED315.3 (VDD), LED316.3 (VDD), LED317.3 (VDD), LED318.3 (VDD), LED319.3 (VDD), LED320.3 (VDD), LED321.3 (VDD), LED322.3 (VDD), LED323.3 (VDD), LED324.3 (VDD), LED325.3 (VDD), LED326.3 (VDD), LED327.3 (VDD), LED328.3 (VDD), LED329.3 (VDD), LED330.3 (VDD), LED331.3 (VDD), LED332.3 (VDD), LED333.3 (VDD), LED334.3 (VDD), LED335.3 (VDD), LED336.3 (VDD), LED337.3 (VDD), LED338.3 (VDD), LED339.3 (VDD), LED340.3 (VDD), LED341.3 (VDD), LED342.3 (VDD), LED343.3 (VDD), LED344.3 (VDD), LED345.3 (VDD), LED346.3 (VDD), LED347.3 (VDD), LED348.3 (VDD), LED349.3 (VDD), LED350.3 (VDD), LED351.3 (VDD), LED352.3 (VDD), LED353.3 (VDD), LED354.3 (VDD), LED355.3 (VDD), LED356.3 (VDD), LED357.3 (VDD), LED358.3 (VDD), LED359.3 (VDD), LED360.3 (VDD), LED361.3 (VDD), LED362.3 (VDD), LED363.3 (VDD), LED364.3 (VDD), LED365.3 (VDD), LED366.3 (VDD), LED367.3 (VDD), LED368.3 (VDD), LED369.3 (VDD), LED370.3 (VDD), LED371.3 (VDD), LED372.3 (VDD), LED373.3 (VDD), LED374.3 (VDD), LED375.3 (VDD), LED376.3 (VDD), LED377.3 (VDD), LED378.3 (VDD), LED379.3 (VDD), LED380.3 (VDD), LED381.3 (VDD), LED382.3 (VDD), LED383.3 (VDD), LED384.3 (VDD), LED385.3 (VDD), LED386.3 (VDD), LED387.3 (VDD), LED388.3 (VDD), LED389.3 (VDD), LED390.3 (VDD), LED391.3 (VDD), LED392.3 (VDD), LED393.3 (VDD), LED394.3 (VDD), LED395.3 (VDD), LED396.3 (VDD), LED397.3 (VDD), LED398.3 (VDD), LED399.3 (VDD), LED400.3 (VDD), LED401.3 (VDD), LED402.3 (VDD), LED403.3 (VDD), LED404.3 (VDD), LED405.3 (VDD), LED406.3 (VDD), LED407.3 (VDD), LED408.3 (VDD), LED409.3 (VDD), LED410.3 (VDD), LED411.3 (VDD), LED412.3 (VDD), LED413.3 (VDD), LED414.3 (VDD), LED415.3 (VDD), LED416.3 (VDD), LED417.3 (VDD), LED418.3 (VDD), LED419.3 (VDD), LED420.3 (VDD), LED421.3 (VDD), LED422.3 (VDD), LED423.3 (VDD), LED424.3 (VDD), LED425.3 (VDD), LED426.3 (VDD), LED427.3 (VDD), LED428.3 (VDD), LED429.3 (VDD), LED430.3 (VDD), LED431.3 (VDD), LED432.3 (VDD), LED433.3 (VDD), LED434.3 (VDD), LED435.3 (VDD), LED436.3 (VDD), LED437.3 (VDD), LED438.3 (VDD), LED439.3 (VDD), LED440.3 (VDD), LED441.3 (VDD), LED442.3 (VDD), LED443.3 (VDD), LED444.3 (VDD), LED445.3 (VDD), LED446.3 (VDD), LED447.3 (VDD), LED448.3 (VDD), LED449.3 (VDD), LED450.3 (VDD), LED451.3 (VDD), LED452.3 (VDD), LED453.3 (VDD), LED454.3 (VDD), LED455.3 (VDD), LED456.3 (VDD), LED457.3 (VDD), LED458.3 (VDD), LED459.3 (VDD), LED460.3 (VDD), LED461.3 (VDD), LED462.3 (VDD), LED463.3 (VDD), LED464.3 (VDD), LED465.3 (VDD), LED466.3 (VDD), LED467.3 (VDD), LED468.3 (VDD), LED469.3 (VDD), LED470.3 (VDD), LED471.3 (VDD), LED472.3 (VDD), LED473.3 (VDD), LED474.3 (VDD), LED475.3 (VDD), LED476.3 (VDD), LED477.3 (VDD), LED478.3 (VDD), LED479.3 (VDD), LED480.3 (VDD), LED481.3 (VDD), LED482.3 (VDD), LED483.3 (VDD), LED484.3 (VDD), LED485.3 (VDD), LED486.3 (VDD), LED487.3 (VDD), LED488.3 (VDD), LED489.3 (VDD), LED490.3 (VDD), LED491.3 (VDD), LED492.3 (VDD), LED493.3 (VDD), LED494.3 (VDD), LED495.3 (VDD), LED496.3 (VDD), LED497.3 (VDD), LED498.3 (VDD), LED499.3 (VDD), LED500.3 (VDD), LED501.3 (VDD), LED502.3 (VDD), LED503.3 (VDD), LED504.3 (VDD), LED505.3 (VDD), LED506.3 (VDD), LED507.3 (VDD), LED508.3 (VDD), LED509.3 (VDD), LED510.3 (VDD), LED511.3 (VDD), LED512.3 (VDD), LED513.3 (VDD), LED514.3 (VDD), LED515.3 (VDD), LED516.3 (VDD), LED517.3 (VDD), LED518.3 (VDD), LED519.3 (VDD), LED520.3 (VDD), LED521.3 (VDD), LED522.3 (VDD), LED523.3 (VDD), LED524.3 (VDD), LED525.3 (VDD), LED526.3 (VDD), LED527.3 (VDD), LED528.3 (VDD), LED529.3 (VDD), LED530.3 (VDD), LED531.3 (VDD), LED532.3 (VDD), LED533.3 (VDD), LED534.3 (VDD), LED535.3 (VDD), LED536.3 (VDD), LED537.3 (VDD), LED538.3 (VDD), LED539.3 (VDD), LED540.3 (VDD), LED541.3 (VDD), LED542.3 (VDD), LED543.3 (VDD), LED544.3 (VDD), LED545.3 (VDD), LED546.3 (VDD), LED547.3 (VDD), LED548.3 (VDD), LED549.3 (VDD)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
BUTTON_01: SW1.1 (A), U1.1 (GPIO26/ADC0/A0)
BUTTON_02: SW3.1 (A), U1.2 (GPIO27/ADC1/A1)
BUTTON_03: SW2.2 (B), U1.3 (GPIO28/ADC2/A2)
BUTTON_04: SW4.2 (B), U1.4 (GPIO29/ADC3/A3)
GND: GND1.1, LED1.1 (GND), LED2.1 (GND), LED3.1 (GND), LED4.1 (GND), LED5.1 (GND), LED6.1 (GND), LED7.1 (GND), LED8.1 (GND), LED9.1 (GND), LED10.1 (GND), LED11.1 (GND), LED12.1 (GND), LED13.1 (GND), LED14.1 (GND), LED15.1 (GND), LED16.1 (GND), LED17.1 (GND), LED18.1 (GND), LED19.1 (GND), LED20.1 (GND), LED21.1 (GND), LED22.1 (GND), LED23.1 (GND), LED24.1 (GND), LED25.1 (GND), LED26.1 (GND), LED27.1 (GND), LED28.1 (GND), LED29.1 (GND), LED30.1 (GND), LED31.1 (GND), LED32.1 (GND), LED33.1 (GND), LED34.1 (GND), LED35.1 (GND), LED36.1 (GND), LED37.1 (GND), LED38.1 (GND), LED39.1 (GND), LED40.1 (GND), LED41.1 (GND), LED42.1 (GND), LED43.1 (GND), LED44.1 (GND), LED45.1 (GND), LED46.1 (GND), LED47.1 (GND), LED48.1 (GND), LED49.1 (GND), LED50.1 (GND), LED51.1 (GND), LED52.1 (GND), LED53.1 (GND), LED54.1 (GND), LED55.1 (GND), LED56.1 (GND), LED57.1 (GND), LED58.1 (GND), LED59.1 (GND), LED60.1 (GND), LED61.1 (GND), LED62.1 (GND), LED63.1 (GND), LED64.1 (GND), LED65.1 (GND), LED66.1 (GND), LED67.1 (GND), LED68.1 (GND), LED69.1 (GND), LED70.1 (GND), LED71.1 (GND), LED72.1 (GND), LED73.1 (GND), LED74.1 (GND), LED75.1 (GND), LED76.1 (GND), LED77.1 (GND), LED78.1 (GND), LED79.1 (GND), LED80.1 (GND), LED81.1 (GND), LED82.1 (GND), LED83.1 (GND), LED84.1 (GND), LED85.1 (GND), LED86.1 (GND), LED87.1 (GND), LED88.1 (GND), LED89.1 (GND), LED90.1 (GND), LED91.1 (GND), LED92.1 (GND), LED93.1 (GND), LED94.1 (GND), LED95.1 (GND), LED96.1 (GND), LED97.1 (GND), LED98.1 (GND), LED99.1 (GND), LED100.1 (GND), LED101.1 (GND), LED102.1 (GND), LED103.1 (GND), LED104.1 (GND), LED105.1 (GND), LED106.1 (GND), LED107.1 (GND), LED108.1 (GND), LED109.1 (GND), LED110.1 (GND), LED111.1 (GND), LED112.1 (GND), LED113.1 (GND), LED114.1 (GND), LED115.1 (GND), LED116.1 (GND), LED117.1 (GND), LED118.1 (GND), LED119.1 (GND), LED120.1 (GND), LED121.1 (GND), LED122.1 (GND), LED123.1 (GND), LED124.1 (GND), LED125.1 (GND), LED126.1 (GND), LED127.1 (GND), LED128.1 (GND), LED129.1 (GND), LED130.1 (GND), LED131.1 (GND), LED132.1 (GND), LED133.1 (GND), LED134.1 (GND), LED135.1 (GND), LED136.1 (GND), LED137.1 (GND), LED138.1 (GND), LED139.1 (GND), LED140.1 (GND), LED141.1 (GND), LED142.1 (GND), LED143.1 (GND), LED144.1 (GND), LED145.1 (GND), LED146.1 (GND), LED147.1 (GND), LED148.1 (GND), LED149.1 (GND), LED150.1 (GND), LED151.1 (GND), LED152.1 (GND), LED153.1 (GND), LED154.1 (GND), LED155.1 (GND), LED156.1 (GND), LED157.1 (GND), LED158.1 (GND), LED159.1 (GND), LED160.1 (GND), LED161.1 (GND), LED162.1 (GND), LED163.1 (GND), LED164.1 (GND), LED165.1 (GND), LED166.1 (GND), LED167.1 (GND), LED168.1 (GND), LED169.1 (GND), LED170.1 (GND), LED171.1 (GND), LED172.1 (GND), LED173.1 (GND), LED174.1 (GND), LED175.1 (GND), LED176.1 (GND), LED177.1 (GND), LED178.1 (GND), LED179.1 (GND), LED180.1 (GND), LED181.1 (GND), LED182.1 (GND), LED183.1 (GND), LED184.1 (GND), LED185.1 (GND), LED186.1 (GND), LED187.1 (GND), LED188.1 (GND), LED189.1 (GND), LED190.1 (GND), LED191.1 (GND), LED192.1 (GND), LED193.1 (GND), LED194.1 (GND), LED195.1 (GND), LED196.1 (GND), LED197.1 (GND), LED198.1 (GND), LED199.1 (GND), LED200.1 (GND), LED201.1 (GND), LED202.1 (GND), LED203.1 (GND), LED204.1 (GND), LED205.1 (GND), LED206.1 (GND), LED207.1 (GND), LED208.1 (GND), LED209.1 (GND), LED210.1 (GND), LED211.1 (GND), LED212.1 (GND), LED213.1 (GND), LED214.1 (GND), LED215.1 (GND), LED216.1 (GND), LED217.1 (GND), LED218.1 (GND), LED219.1 (GND), LED220.1 (GND), LED221.1 (GND), LED222.1 (GND), LED223.1 (GND), LED224.1 (GND), LED225.1 (GND), LED226.1 (GND), LED227.1 (GND), LED228.1 (GND), LED229.1 (GND), LED230.1 (GND), LED231.1 (GND), LED232.1 (GND), LED233.1 (GND), LED234.1 (GND), LED235.1 (GND), LED236.1 (GND), LED237.1 (GND), LED238.1 (GND), LED239.1 (GND), LED240.1 (GND), LED241.1 (GND), LED242.1 (GND), LED243.1 (GND), LED244.1 (GND), LED245.1 (GND), LED246.1 (GND), LED247.1 (GND), LED248.1 (GND), LED249.1 (GND), LED250.1 (GND), LED251.1 (GND), LED252.1 (GND), LED253.1 (GND), LED254.1 (GND), LED255.1 (GND), LED256.1 (GND), LED257.1 (GND), LED258.1 (GND), LED259.1 (GND), LED260.1 (GND), LED261.1 (GND), LED262.1 (GND), LED263.1 (GND), LED264.1 (GND), LED265.1 (GND), LED266.1 (GND), LED267.1 (GND), LED268.1 (GND), LED269.1 (GND), LED270.1 (GND), LED271.1 (GND), LED272.1 (GND), LED273.1 (GND), LED274.1 (GND), LED275.1 (GND), LED276.1 (GND), LED277.1 (GND), LED278.1 (GND), LED279.1 (GND), LED280.1 (GND), LED281.1 (GND), LED282.1 (GND), LED283.1 (GND), LED284.1 (GND), LED285.1 (GND), LED286.1 (GND), LED287.1 (GND), LED288.1 (GND), LED289.1 (GND), LED290.1 (GND), LED291.1 (GND), LED292.1 (GND), LED293.1 (GND), LED294.1 (GND), LED295.1 (GND), LED296.1 (GND), LED297.1 (GND), LED298.1 (GND), LED299.1 (GND), LED300.1 (GND), LED301.1 (GND), LED302.1 (GND), LED303.1 (GND), LED304.1 (GND), LED305.1 (GND), LED306.1 (GND), LED307.1 (GND), LED308.1 (GND), LED309.1 (GND), LED310.1 (GND), LED311.1 (GND), LED312.1 (GND), LED313.1 (GND), LED314.1 (GND), LED315.1 (GND), LED316.1 (GND), LED317.1 (GND), LED318.1 (GND), LED319.1 (GND), LED320.1 (GND), LED321.1 (GND), LED322.1 (GND), LED323.1 (GND), LED324.1 (GND), LED325.1 (GND), LED326.1 (GND), LED327.1 (GND), LED328.1 (GND), LED329.1 (GND), LED330.1 (GND), LED331.1 (GND), LED332.1 (GND), LED333.1 (GND), LED334.1 (GND), LED335.1 (GND), LED336.1 (GND), LED337.1 (GND), LED338.1 (GND), LED339.1 (GND), LED340.1 (GND), LED341.1 (GND), LED342.1 (GND), LED343.1 (GND), LED344.1 (GND), LED345.1 (GND), LED346.1 (GND), LED347.1 (GND), LED348.1 (GND), LED349.1 (GND), LED350.1 (GND), LED351.1 (GND), LED352.1 (GND), LED353.1 (GND), LED354.1 (GND), LED355.1 (GND), LED356.1 (GND), LED357.1 (GND), LED358.1 (GND), LED359.1 (GND), LED360.1 (GND), LED361.1 (GND), LED362.1 (GND), LED363.1 (GND), LED364.1 (GND), LED365.1 (GND), LED366.1 (GND), LED367.1 (GND), LED368.1 (GND), LED369.1 (GND), LED370.1 (GND), LED371.1 (GND), LED372.1 (GND), LED373.1 (GND), LED374.1 (GND), LED375.1 (GND), LED376.1 (GND), LED377.1 (GND), LED378.1 (GND), LED379.1 (GND), LED380.1 (GND), LED381.1 (GND), LED382.1 (GND), LED383.1 (GND), LED384.1 (GND), LED385.1 (GND), LED386.1 (GND), LED387.1 (GND), LED388.1 (GND), LED389.1 (GND), LED390.1 (GND), LED391.1 (GND), LED392.1 (GND), LED393.1 (GND), LED394.1 (GND), LED395.1 (GND), LED396.1 (GND), LED397.1 (GND), LED398.1 (GND), LED399.1 (GND), LED400.1 (GND), LED401.1 (GND), LED402.1 (GND), LED403.1 (GND), LED404.1 (GND), LED405.1 (GND), LED406.1 (GND), LED407.1 (GND), LED408.1 (GND), LED409.1 (GND), LED410.1 (GND), LED411.1 (GND), LED412.1 (GND), LED413.1 (GND), LED414.1 (GND), LED415.1 (GND), LED416.1 (GND), LED417.1 (GND), LED418.1 (GND), LED419.1 (GND), LED420.1 (GND), LED421.1 (GND), LED422.1 (GND), LED423.1 (GND), LED424.1 (GND), LED425.1 (GND), LED426.1 (GND), LED427.1 (GND), LED428.1 (GND), LED429.1 (GND), LED430.1 (GND), LED431.1 (GND), LED432.1 (GND), LED433.1 (GND), LED434.1 (GND), LED435.1 (GND), LED436.1 (GND), LED437.1 (GND), LED438.1 (GND), LED439.1 (GND), LED440.1 (GND), LED441.1 (GND), LED442.1 (GND), LED443.1 (GND), LED444.1 (GND), LED445.1 (GND), LED446.1 (GND), LED447.1 (GND), LED448.1 (GND), LED449.1 (GND), LED450.1 (GND), LED451.1 (GND), LED452.1 (GND), LED453.1 (GND), LED454.1 (GND), LED455.1 (GND), LED456.1 (GND), LED457.1 (GND), LED458.1 (GND), LED459.1 (GND), LED460.1 (GND), LED461.1 (GND), LED462.1 (GND), LED463.1 (GND), LED464.1 (GND), LED465.1 (GND), LED466.1 (GND), LED467.1 (GND), LED468.1 (GND), LED469.1 (GND), LED470.1 (GND), LED471.1 (GND), LED472.1 (GND), LED473.1 (GND), LED474.1 (GND), LED475.1 (GND), LED476.1 (GND), LED477.1 (GND), LED478.1 (GND), LED479.1 (GND), LED480.1 (GND), LED481.1 (GND), LED482.1 (GND), LED483.1 (GND), LED484.1 (GND), LED485.1 (GND), LED486.1 (GND), LED487.1 (GND), LED488.1 (GND), LED489.1 (GND), LED490.1 (GND), LED491.1 (GND), LED492.1 (GND), LED493.1 (GND), LED494.1 (GND), LED495.1 (GND), LED496.1 (GND), LED497.1 (GND), LED498.1 (GND), LED499.1 (GND), LED500.1 (GND), LED501.1 (GND), LED502.1 (GND), LED503.1 (GND), LED504.1 (GND), LED505.1 (GND), LED506.1 (GND), LED507.1 (GND), LED508.1 (GND), LED509.1 (GND), LED510.1 (GND), LED511.1 (GND), LED512.1 (GND), LED513.1 (GND), LED514.1 (GND), LED515.1 (GND), LED516.1 (GND), LED517.1 (GND), LED518.1 (GND), LED519.1 (GND), LED520.1 (GND), LED521.1 (GND), LED522.1 (GND), LED523.1 (GND), LED524.1 (GND), LED525.1 (GND), LED526.1 (GND), LED527.1 (GND), LED528.1 (GND), LED529.1 (GND), LED530.1 (GND), LED531.1 (GND), LED532.1 (GND), LED533.1 (GND), LED534.1 (GND), LED535.1 (GND), LED536.1 (GND), LED537.1 (GND), LED538.1 (GND), LED539.1 (GND), LED540.1 (GND), LED541.1 (GND), LED542.1 (GND), LED543.1 (GND), LED544.1 (GND), LED545.1 (GND), LED546.1 (GND), LED547.1 (GND), LED548.1 (GND), LED549.1 (GND), LED550.1 (GND), LED551.1 (GND), LED552.1 (GND), LED553.1 (GND), LED554.1 (GND), LED555.1 (GND), LED556.1 (GND)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
LED_IN: LED_IN1.1, R2.1, U1.8 (GPIO1/RX)
unnamed: LED1.2 (DI), R2.2
unnamed: LED1.4 (DO), LED2.2 (DI)
unnamed: LED2.4 (DO), LED3.2 (DI)
unnamed: LED3.4 (DO), LED4.2 (DI)
unnamed: LED4.4 (DO), LED5.2 (DI)
unnamed: LED5.4 (DO), LED6.2 (DI)
unnamed: LED6.4 (DO), LED7.2 (DI)
unnamed: LED7.4 (DO), LED8.2 (DI)
unnamed: LED8.4 (DO), LED9.2 (DI)
unnamed: LED9.4 (DO), LED10.2 (DI)
unnamed: LED11.4 (DO), LED12.2 (DI)
unnamed: LED12.4 (DO), LED13.2 (DI)
unnamed: LED13.4 (DO), LED14.2 (DI)
unnamed: LED14.4 (DO), LED15.2 (DI)
unnamed: LED15.4 (DO), LED16.2 (DI)
unnamed: LED16.4 (DO), LED17.2 (DI)
unnamed: LED17.4 (DO), LED18.2 (DI)
unnamed: LED18.4 (DO), LED19.2 (DI)
unnamed: LED19.4 (DO), LED20.2 (DI)
unnamed: LED21.4 (DO), LED22.2 (DI)
unnamed: LED22.4 (DO), LED23.2 (DI)
unnamed: LED23.4 (DO), LED24.2 (DI)
unnamed: LED24.4 (DO), LED25.2 (DI)
unnamed: LED25.4 (DO), LED26.2 (DI)
unnamed: LED26.4 (DO), LED27.2 (DI)
unnamed: LED27.4 (DO), LED28.2 (DI)
unnamed: LED28.4 (DO), LED29.2 (DI)
unnamed: LED29.4 (DO), LED30.2 (DI)
unnamed: LED31.4 (DO), LED32.2 (DI)
unnamed: LED32.4 (DO), LED33.2 (DI)
unnamed: LED33.4 (DO), LED34.2 (DI)
unnamed: LED34.4 (DO), LED35.2 (DI)
unnamed: LED35.4 (DO), LED36.2 (DI)
unnamed: LED36.4 (DO), LED37.2 (DI)
unnamed: LED37.4 (DO), LED38.2 (DI)
unnamed: LED38.4 (DO), LED39.2 (DI)
unnamed: LED39.4 (DO), LED40.2 (DI)
unnamed: LED41.4 (DO), LED42.2 (DI)
unnamed: LED42.4 (DO), LED43.2 (DI)
unnamed: LED43.4 (DO), LED44.2 (DI)
unnamed: LED44.4 (DO), LED45.2 (DI)
unnamed: LED45.4 (DO), LED46.2 (DI)
unnamed: LED46.4 (DO), LED47.2 (DI)
unnamed: LED47.4 (DO), LED48.2 (DI)
unnamed: LED48.4 (DO), LED49.2 (DI)
unnamed: LED49.4 (DO), LED50.2 (DI)
unnamed: LED51.4 (DO), LED52.2 (DI)
unnamed: LED52.4 (DO), LED53.2 (DI)
unnamed: LED53.4 (DO), LED54.2 (DI)
unnamed: LED54.4 (DO), LED55.2 (DI)
unnamed: LED55.4 (DO), LED56.2 (DI)
unnamed: LED56.4 (DO), LED57.2 (DI)
unnamed: LED57.4 (DO), LED58.2 (DI)
unnamed: LED58.4 (DO), LED59.2 (DI)
unnamed: LED59.4 (DO), LED60.2 (DI)
unnamed: LED61.4 (DO), LED62.2 (DI)
unnamed: LED62.4 (DO), LED63.2 (DI)
unnamed: LED63.4 (DO), LED64.2 (DI)
unnamed: LED64.4 (DO), LED65.2 (DI)
unnamed: LED65.4 (DO), LED66.2 (DI)
unnamed: LED66.4 (DO), LED67.2 (DI)
unnamed: LED67.4 (DO), LED68.2 (DI)
unnamed: LED68.4 (DO), LED69.2 (DI)
unnamed: LED69.4 (DO), LED70.2 (DI)
unnamed: LED71.4 (DO), LED72.2 (DI)
unnamed: LED72.4 (DO), LED73.2 (DI)
unnamed: LED73.4 (DO), LED74.2 (DI)
unnamed: LED74.4 (DO), LED75.2 (DI)
unnamed: LED75.4 (DO), LED76.2 (DI)
unnamed: LED76.4 (DO), LED77.2 (DI)
unnamed: LED77.4 (DO), LED78.2 (DI)
unnamed: LED78.4 (DO), LED79.2 (DI)
unnamed: LED79.4 (DO), LED80.2 (DI)
unnamed: LED81.4 (DO), LED82.2 (DI)
unnamed: LED82.4 (DO), LED83.2 (DI)
unnamed: LED83.4 (DO), LED84.2 (DI)
unnamed: LED84.4 (DO), LED85.2 (DI)
unnamed: LED85.4 (DO), LED86.2 (DI)
unnamed: LED86.4 (DO), LED87.2 (DI)
unnamed: LED87.4 (DO), LED88.2 (DI)
unnamed: LED88.4 (DO), LED89.2 (DI)
unnamed: LED89.4 (DO), LED90.2 (DI)
unnamed: LED91.4 (DO), LED92.2 (DI)
unnamed: LED92.4 (DO), LED93.2 (DI)
unnamed: LED93.4 (DO), LED94.2 (DI)
unnamed: LED94.4 (DO), LED95.2 (DI)
unnamed: LED95.4 (DO), LED96.2 (DI)
unnamed: LED96.4 (DO), LED97.2 (DI)
unnamed: LED97.4 (DO), LED98.2 (DI)
unnamed: LED98.4 (DO), LED99.2 (DI)
unnamed: LED99.4 (DO), LED100.2 (DI)
unnamed: LED100.4 (DO), R1.1
unnamed: LED101.4 (DO), LED102.2 (DI)
unnamed: LED102.4 (DO), LED103.2 (DI)
unnamed: LED103.4 (DO), LED104.2 (DI)
unnamed: LED104.4 (DO), LED105.2 (DI)
unnamed: LED105.4 (DO), LED106.2 (DI)
unnamed: LED106.4 (DO), LED107.2 (DI)
unnamed: LED107.4 (DO), LED108.2 (DI)
unnamed: LED108.4 (DO), LED109.2 (DI)
unnamed: LED109.4 (DO), LED110.2 (DI)
unnamed: LED111.4 (DO), LED112.2 (DI)
unnamed: LED112.4 (DO), LED113.2 (DI)
unnamed: LED113.4 (DO), LED114.2 (DI)
unnamed: LED114.4 (DO), LED115.2 (DI)
unnamed: LED115.4 (DO), LED116.2 (DI)
unnamed: LED116.4 (DO), LED117.2 (DI)
unnamed: LED117.4 (DO), LED118.2 (DI)
unnamed: LED118.4 (DO), LED119.2 (DI)
unnamed: LED119.4 (DO), LED120.2 (DI)
unnamed: LED121.4 (DO), LED122.2 (DI)
unnamed: LED122.4 (DO), LED123.2 (DI)
unnamed: LED123.4 (DO), LED124.2 (DI)
unnamed: LED124.4 (DO), LED125.2 (DI)
unnamed: LED125.4 (DO), LED126.2 (DI)
unnamed: LED126.4 (DO), LED127.2 (DI)
unnamed: LED127.4 (DO), LED128.2 (DI)
unnamed: LED128.4 (DO), LED129.2 (DI)
unnamed: LED129.4 (DO), LED130.2 (DI)
unnamed: LED131.4 (DO), LED132.2 (DI)
unnamed: LED132.4 (DO), LED133.2 (DI)
unnamed: LED133.4 (DO), LED134.2 (DI)
unnamed: LED134.4 (DO), LED135.2 (DI)
unnamed: LED135.4 (DO), LED136.2 (DI)
unnamed: LED136.4 (DO), LED137.2 (DI)
unnamed: LED137.4 (DO), LED138.2 (DI)
unnamed: LED138.4 (DO), LED139.2 (DI)
unnamed: LED139.4 (DO), LED140.2 (DI)
unnamed: LED141.4 (DO), LED142.2 (DI)
unnamed: LED142.4 (DO), LED143.2 (DI)
unnamed: LED143.4 (DO), LED144.2 (DI)
unnamed: LED144.4 (DO), LED145.2 (DI)
unnamed: LED145.4 (DO), LED146.2 (DI)
unnamed: LED146.4 (DO), LED147.2 (DI)
unnamed: LED147.4 (DO), LED148.2 (DI)
unnamed: LED148.4 (DO), LED149.2 (DI)
unnamed: LED149.4 (DO), LED150.2 (DI)
unnamed: LED151.4 (DO), LED152.2 (DI)
unnamed: LED152.4 (DO), LED153.2 (DI)
unnamed: LED153.4 (DO), LED154.2 (DI)
unnamed: LED154.4 (DO), LED155.2 (DI)
unnamed: LED155.4 (DO), LED156.2 (DI)
unnamed: LED156.4 (DO), LED157.2 (DI)
unnamed: LED157.4 (DO), LED158.2 (DI)
unnamed: LED158.4 (DO), LED159.2 (DI)
unnamed: LED159.4 (DO), LED160.2 (DI)
unnamed: LED161.4 (DO), LED162.2 (DI)
unnamed: LED162.4 (DO), LED163.2 (DI)
unnamed: LED163.4 (DO), LED164.2 (DI)
unnamed: LED164.4 (DO), LED165.2 (DI)
unnamed: LED165.4 (DO), LED166.2 (DI)
unnamed: LED166.4 (DO), LED167.2 (DI)
unnamed: LED167.4 (DO), LED168.2 (DI)
unnamed: LED168.4 (DO), LED169.2 (DI)
unnamed: LED169.4 (DO), LED170.2 (DI)
unnamed: LED171.4 (DO), LED172.2 (DI)
unnamed: LED172.4 (DO), LED173.2 (DI)
unnamed: LED173.4 (DO), LED174.2 (DI)
unnamed: LED174.4 (DO), LED175.2 (DI)
unnamed: LED175.4 (DO), LED176.2 (DI)
unnamed: LED176.4 (DO), LED177.2 (DI)
unnamed: LED177.4 (DO), LED178.2 (DI)
unnamed: LED178.4 (DO), LED179.2 (DI)
unnamed: LED179.4 (DO), LED180.2 (DI)
unnamed: LED181.4 (DO), LED182.2 (DI)
unnamed: LED182.4 (DO), LED183.2 (DI)
unnamed: LED183.4 (DO), LED184.2 (DI)
unnamed: LED184.4 (DO), LED185.2 (DI)
unnamed: LED185.4 (DO), LED186.2 (DI)
unnamed: LED186.4 (DO), LED187.2 (DI)
unnamed: LED187.4 (DO), LED188.2 (DI)
unnamed: LED188.4 (DO), LED189.2 (DI)
unnamed: LED189.4 (DO), LED190.2 (DI)
unnamed: LED191.4 (DO), LED192.2 (DI)
unnamed: LED192.4 (DO), LED193.2 (DI)
unnamed: LED193.4 (DO), LED194.2 (DI)
unnamed: LED194.4 (DO), LED195.2 (DI)
unnamed: LED195.4 (DO), LED196.2 (DI)
unnamed: LED196.4 (DO), LED197.2 (DI)
unnamed: LED197.4 (DO), LED198.2 (DI)
unnamed: LED198.4 (DO), LED199.2 (DI)
unnamed: LED199.4 (DO), LED200.2 (DI)
unnamed: LED200.4 (DO), R3.1
unnamed: LED201.4 (DO), LED202.2 (DI)
unnamed: LED202.4 (DO), LED203.2 (DI)
unnamed: LED203.4 (DO), LED204.2 (DI)
unnamed: LED204.4 (DO), LED205.2 (DI)
unnamed: LED205.4 (DO), LED206.2 (DI)
unnamed: LED206.4 (DO), LED207.2 (DI)
unnamed: LED207.4 (DO), LED208.2 (DI)
unnamed: LED208.4 (DO), LED209.2 (DI)
unnamed: LED209.4 (DO), LED210.2 (DI)
unnamed: LED211.4 (DO), LED212.2 (DI)
unnamed: LED212.4 (DO), LED213.2 (DI)
unnamed: LED213.4 (DO), LED214.2 (DI)
unnamed: LED214.4 (DO), LED215.2 (DI)
unnamed: LED215.4 (DO), LED216.2 (DI)
unnamed: LED216.4 (DO), LED217.2 (DI)
unnamed: LED217.4 (DO), LED218.2 (DI)
unnamed: LED218.4 (DO), LED219.2 (DI)
unnamed: LED219.4 (DO), LED220.2 (DI)
unnamed: LED221.4 (DO), LED222.2 (DI)
unnamed: LED222.4 (DO), LED223.2 (DI)
unnamed: LED223.4 (DO), LED224.2 (DI)
unnamed: LED224.4 (DO), LED225.2 (DI)
unnamed: LED225.4 (DO), LED226.2 (DI)
unnamed: LED226.4 (DO), LED227.2 (DI)
unnamed: LED227.4 (DO), LED228.2 (DI)
unnamed: LED228.4 (DO), LED229.2 (DI)
unnamed: LED229.4 (DO), LED230.2 (DI)
unnamed: LED231.4 (DO), LED232.2 (DI)
unnamed: LED232.4 (DO), LED233.2 (DI)
unnamed: LED233.4 (DO), LED234.2 (DI)
unnamed: LED234.4 (DO), LED235.2 (DI)
unnamed: LED235.4 (DO), LED236.2 (DI)
unnamed: LED236.4 (DO), LED237.2 (DI)
unnamed: LED237.4 (DO), LED238.2 (DI)
unnamed: LED238.4 (DO), LED239.2 (DI)
unnamed: LED239.4 (DO), LED240.2 (DI)
unnamed: LED241.4 (DO), LED242.2 (DI)
unnamed: LED242.4 (DO), LED243.2 (DI)
unnamed: LED243.4 (DO), LED244.2 (DI)
unnamed: LED244.4 (DO), LED245.2 (DI)
unnamed: LED245.4 (DO), LED246.2 (DI)
unnamed: LED246.4 (DO), LED247.2 (DI)
unnamed: LED247.4 (DO), LED248.2 (DI)
unnamed: LED248.4 (DO), LED249.2 (DI)
unnamed: LED249.4 (DO), LED250.2 (DI)
unnamed: LED251.4 (DO), LED252.2 (DI)
unnamed: LED252.4 (DO), LED253.2 (DI)
unnamed: LED253.4 (DO), LED254.2 (DI)
unnamed: LED254.4 (DO), LED255.2 (DI)
unnamed: LED255.4 (DO), LED256.2 (DI)
unnamed: LED256.4 (DO), LED257.2 (DI)
unnamed: LED257.4 (DO), LED258.2 (DI)
unnamed: LED258.4 (DO), LED259.2 (DI)
unnamed: LED259.4 (DO), LED260.2 (DI)
unnamed: LED261.4 (DO), LED262.2 (DI)
unnamed: LED262.4 (DO), LED263.2 (DI)
unnamed: LED263.4 (DO), LED264.2 (DI)
unnamed: LED264.4 (DO), LED265.2 (DI)
unnamed: LED265.4 (DO), LED266.2 (DI)
unnamed: LED266.4 (DO), LED267.2 (DI)
unnamed: LED267.4 (DO), LED268.2 (DI)
unnamed: LED268.4 (DO), LED269.2 (DI)
unnamed: LED269.4 (DO), LED270.2 (DI)
unnamed: LED271.4 (DO), LED272.2 (DI)
unnamed: LED272.4 (DO), LED273.2 (DI)
unnamed: LED273.4 (DO), LED274.2 (DI)
unnamed: LED274.4 (DO), LED275.2 (DI)
unnamed: LED275.4 (DO), LED276.2 (DI)
unnamed: LED276.4 (DO), LED277.2 (DI)
unnamed: LED277.4 (DO), LED278.2 (DI)
unnamed: LED278.4 (DO), LED279.2 (DI)
unnamed: LED279.4 (DO), LED280.2 (DI)
unnamed: LED281.4 (DO), LED282.2 (DI)
unnamed: LED282.4 (DO), LED283.2 (DI)
unnamed: LED283.4 (DO), LED284.2 (DI)
unnamed: LED284.4 (DO), LED285.2 (DI)
unnamed: LED285.4 (DO), LED286.2 (DI)
unnamed: LED286.4 (DO), LED287.2 (DI)
unnamed: LED287.4 (DO), LED288.2 (DI)
unnamed: LED288.4 (DO), LED289.2 (DI)
unnamed: LED289.4 (DO), LED290.2 (DI)
unnamed: LED291.4 (DO), LED292.2 (DI)
unnamed: LED292.4 (DO), LED293.2 (DI)
unnamed: LED293.4 (DO), LED294.2 (DI)
unnamed: LED294.4 (DO), LED295.2 (DI)
unnamed: LED295.4 (DO), LED296.2 (DI)
unnamed: LED296.4 (DO), LED297.2 (DI)
unnamed: LED297.4 (DO), LED298.2 (DI)
unnamed: LED298.4 (DO), LED299.2 (DI)
unnamed: LED299.4 (DO), LED300.2 (DI)
unnamed: LED300.4 (DO), R4.1
unnamed: LED301.4 (DO), LED302.2 (DI)
unnamed: LED302.4 (DO), LED303.2 (DI)
unnamed: LED303.4 (DO), LED304.2 (DI)
unnamed: LED304.4 (DO), LED305.2 (DI)
unnamed: LED305.4 (DO), LED306.2 (DI)
unnamed: LED306.4 (DO), LED307.2 (DI)
unnamed: LED307.4 (DO), LED308.2 (DI)
unnamed: LED308.4 (DO), LED309.2 (DI)
unnamed: LED309.4 (DO), LED310.2 (DI)
unnamed: LED311.4 (DO), LED312.2 (DI)
unnamed: LED312.4 (DO), LED313.2 (DI)
unnamed: LED313.4 (DO), LED314.2 (DI)
unnamed: LED314.4 (DO), LED315.2 (DI)
unnamed: LED315.4 (DO), LED316.2 (DI)
unnamed: LED316.4 (DO), LED317.2 (DI)
unnamed: LED317.4 (DO), LED318.2 (DI)
unnamed: LED318.4 (DO), LED319.2 (DI)
unnamed: LED319.4 (DO), LED320.2 (DI)
unnamed: LED321.4 (DO), LED322.2 (DI)
unnamed: LED322.4 (DO), LED323.2 (DI)
unnamed: LED323.4 (DO), LED324.2 (DI)
unnamed: LED324.4 (DO), LED325.2 (DI)
unnamed: LED325.4 (DO), LED326.2 (DI)
unnamed: LED326.4 (DO), LED327.2 (DI)
unnamed: LED327.4 (DO), LED328.2 (DI)
unnamed: LED328.4 (DO), LED329.2 (DI)
unnamed: LED329.4 (DO), LED330.2 (DI)
unnamed: LED331.4 (DO), LED332.2 (DI)
unnamed: LED332.4 (DO), LED333.2 (DI)
unnamed: LED333.4 (DO), LED334.2 (DI)
unnamed: LED334.4 (DO), LED335.2 (DI)
unnamed: LED335.4 (DO), LED336.2 (DI)
unnamed: LED336.4 (DO), LED337.2 (DI)
unnamed: LED337.4 (DO), LED338.2 (DI)
unnamed: LED338.4 (DO), LED339.2 (DI)
unnamed: LED339.4 (DO), LED340.2 (DI)
unnamed: LED341.4 (DO), LED342.2 (DI)
unnamed: LED342.4 (DO), LED343.2 (DI)
unnamed: LED343.4 (DO), LED344.2 (DI)
unnamed: LED344.4 (DO), LED345.2 (DI)
unnamed: LED345.4 (DO), LED346.2 (DI)
unnamed: LED346.4 (DO), LED347.2 (DI)
unnamed: LED347.4 (DO), LED348.2 (DI)
unnamed: LED348.4 (DO), LED349.2 (DI)
unnamed: LED349.4 (DO), LED350.2 (DI)
unnamed: LED351.4 (DO), LED352.2 (DI)
unnamed: LED352.4 (DO), LED353.2 (DI)
unnamed: LED353.4 (DO), LED354.2 (DI)
unnamed: LED354.4 (DO), LED355.2 (DI)
unnamed: LED355.4 (DO), LED356.2 (DI)
unnamed: LED356.4 (DO), LED357.2 (DI)
unnamed: LED357.4 (DO), LED358.2 (DI)
unnamed: LED358.4 (DO), LED359.2 (DI)
unnamed: LED359.4 (DO), LED360.2 (DI)
unnamed: LED361.4 (DO), LED362.2 (DI)
unnamed: LED362.4 (DO), LED363.2 (DI)
unnamed: LED363.4 (DO), LED364.2 (DI)
unnamed: LED364.4 (DO), LED365.2 (DI)
unnamed: LED365.4 (DO), LED366.2 (DI)
unnamed: LED366.4 (DO), LED367.2 (DI)
unnamed: LED367.4 (DO), LED368.2 (DI)
unnamed: LED368.4 (DO), LED369.2 (DI)
unnamed: LED369.4 (DO), LED370.2 (DI)
unnamed: LED371.4 (DO), LED372.2 (DI)
unnamed: LED372.4 (DO), LED373.2 (DI)
unnamed: LED373.4 (DO), LED374.2 (DI)
unnamed: LED374.4 (DO), LED375.2 (DI)
unnamed: LED375.4 (DO), LED376.2 (DI)
unnamed: LED376.4 (DO), LED377.2 (DI)
unnamed: LED377.4 (DO), LED378.2 (DI)
unnamed: LED378.4 (DO), LED379.2 (DI)
unnamed: LED379.4 (DO), LED380.2 (DI)
unnamed: LED381.4 (DO), LED382.2 (DI)
unnamed: LED382.4 (DO), LED383.2 (DI)
unnamed: LED383.4 (DO), LED384.2 (DI)
unnamed: LED384.4 (DO), LED385.2 (DI)
unnamed: LED385.4 (DO), LED386.2 (DI)
unnamed: LED386.4 (DO), LED387.2 (DI)
unnamed: LED387.4 (DO), LED388.2 (DI)
unnamed: LED388.4 (DO), LED389.2 (DI)
unnamed: LED389.4 (DO), LED390.2 (DI)
unnamed: LED391.4 (DO), LED392.2 (DI)
unnamed: LED392.4 (DO), LED393.2 (DI)
unnamed: LED393.4 (DO), LED394.2 (DI)
unnamed: LED394.4 (DO), LED395.2 (DI)
unnamed: LED395.4 (DO), LED396.2 (DI)
unnamed: LED396.4 (DO), LED397.2 (DI)
unnamed: LED397.4 (DO), LED398.2 (DI)
unnamed: LED398.4 (DO), LED399.2 (DI)
unnamed: LED399.4 (DO), LED400.2 (DI)
unnamed: LED400.4 (DO), R5.1
unnamed: LED401.4 (DO), LED402.2 (DI)
unnamed: LED402.4 (DO), LED403.2 (DI)
unnamed: LED403.4 (DO), LED404.2 (DI)
unnamed: LED404.4 (DO), LED405.2 (DI)
unnamed: LED405.4 (DO), LED406.2 (DI)
unnamed: LED406.4 (DO), LED407.2 (DI)
unnamed: LED407.4 (DO), LED408.2 (DI)
unnamed: LED408.4 (DO), LED409.2 (DI)
unnamed: LED409.4 (DO), LED410.2 (DI)
unnamed: LED411.4 (DO), LED412.2 (DI)
unnamed: LED412.4 (DO), LED413.2 (DI)
unnamed: LED413.4 (DO), LED414.2 (DI)
unnamed: LED414.4 (DO), LED415.2 (DI)
unnamed: LED415.4 (DO), LED416.2 (DI)
unnamed: LED416.4 (DO), LED417.2 (DI)
unnamed: LED417.4 (DO), LED418.2 (DI)
unnamed: LED418.4 (DO), LED419.2 (DI)
unnamed: LED419.4 (DO), LED420.2 (DI)
unnamed: LED421.4 (DO), LED422.2 (DI)
unnamed: LED422.4 (DO), LED423.2 (DI)
unnamed: LED423.4 (DO), LED424.2 (DI)
unnamed: LED424.4 (DO), LED425.2 (DI)
unnamed: LED425.4 (DO), LED426.2 (DI)
unnamed: LED426.4 (DO), LED427.2 (DI)
unnamed: LED427.4 (DO), LED428.2 (DI)
unnamed: LED428.4 (DO), LED429.2 (DI)
unnamed: LED429.4 (DO), LED430.2 (DI)
unnamed: LED431.4 (DO), LED432.2 (DI)
unnamed: LED432.4 (DO), LED433.2 (DI)
unnamed: LED433.4 (DO), LED434.2 (DI)
unnamed: LED434.4 (DO), LED435.2 (DI)
unnamed: LED435.4 (DO), LED436.2 (DI)
unnamed: LED436.4 (DO), LED437.2 (DI)
unnamed: LED437.4 (DO), LED438.2 (DI)
unnamed: LED438.4 (DO), LED439.2 (DI)
unnamed: LED439.4 (DO), LED440.2 (DI)
unnamed: LED441.4 (DO), LED442.2 (DI)
unnamed: LED442.4 (DO), LED443.2 (DI)
unnamed: LED443.4 (DO), LED444.2 (DI)
unnamed: LED444.4 (DO), LED445.2 (DI)
unnamed: LED445.4 (DO), LED446.2 (DI)
unnamed: LED446.4 (DO), LED447.2 (DI)
unnamed: LED447.4 (DO), LED448.2 (DI)
unnamed: LED448.4 (DO), LED449.2 (DI)
unnamed: LED449.4 (DO), LED450.2 (DI)
unnamed: LED451.4 (DO), LED452.2 (DI)
unnamed: LED452.4 (DO), LED453.2 (DI)
unnamed: LED453.4 (DO), LED454.2 (DI)
unnamed: LED454.4 (DO), LED455.2 (DI)
unnamed: LED455.4 (DO), LED456.2 (DI)
unnamed: LED456.4 (DO), LED457.2 (DI)
unnamed: LED457.4 (DO), LED458.2 (DI)
unnamed: LED458.4 (DO), LED459.2 (DI)
unnamed: LED459.4 (DO), LED460.2 (DI)
unnamed: LED461.4 (DO), LED462.2 (DI)
unnamed: LED462.4 (DO), LED463.2 (DI)
unnamed: LED463.4 (DO), LED464.2 (DI)
unnamed: LED464.4 (DO), LED465.2 (DI)
unnamed: LED465.4 (DO), LED466.2 (DI)
unnamed: LED466.4 (DO), LED467.2 (DI)
unnamed: LED467.4 (DO), LED468.2 (DI)
unnamed: LED468.4 (DO), LED469.2 (DI)
unnamed: LED469.4 (DO), LED470.2 (DI)
unnamed: LED471.4 (DO), LED472.2 (DI)
unnamed: LED472.4 (DO), LED473.2 (DI)
unnamed: LED473.4 (DO), LED474.2 (DI)
unnamed: LED474.4 (DO), LED475.2 (DI)
unnamed: LED475.4 (DO), LED476.2 (DI)
unnamed: LED476.4 (DO), LED477.2 (DI)
unnamed: LED477.4 (DO), LED478.2 (DI)
unnamed: LED478.4 (DO), LED479.2 (DI)
unnamed: LED479.4 (DO), LED480.2 (DI)
unnamed: LED481.4 (DO), LED482.2 (DI)
unnamed: LED482.4 (DO), LED483.2 (DI)
unnamed: LED483.4 (DO), LED484.2 (DI)
unnamed: LED484.4 (DO), LED485.2 (DI)
unnamed: LED485.4 (DO), LED486.2 (DI)
unnamed: LED486.4 (DO), LED487.2 (DI)
unnamed: LED487.4 (DO), LED488.2 (DI)
unnamed: LED488.4 (DO), LED489.2 (DI)
unnamed: LED489.4 (DO), LED490.2 (DI)
unnamed: LED491.4 (DO), LED492.2 (DI)
unnamed: LED492.4 (DO), LED493.2 (DI)
unnamed: LED493.4 (DO), LED494.2 (DI)
unnamed: LED494.4 (DO), LED495.2 (DI)
unnamed: LED495.4 (DO), LED496.2 (DI)
unnamed: LED496.4 (DO), LED497.2 (DI)
unnamed: LED497.4 (DO), LED498.2 (DI)
unnamed: LED498.4 (DO), LED499.2 (DI)
unnamed: LED499.4 (DO), LED500.2 (DI)
unnamed: LED500.4 (DO), R6.1
unnamed: LED501.4 (DO), LED502.2 (DI)
unnamed: LED502.4 (DO), LED503.2 (DI)
unnamed: LED503.4 (DO), LED504.2 (DI)
unnamed: LED504.4 (DO), LED505.2 (DI)
unnamed: LED505.4 (DO), LED506.2 (DI)
unnamed: LED506.4 (DO), LED507.2 (DI)
unnamed: LED507.4 (DO), LED508.2 (DI)
unnamed: LED508.4 (DO), LED509.2 (DI)
unnamed: LED509.4 (DO), LED510.2 (DI)
unnamed: LED511.4 (DO), LED512.2 (DI)
unnamed: LED512.4 (DO), LED513.2 (DI)
unnamed: LED513.4 (DO), LED514.2 (DI)
unnamed: LED514.4 (DO), LED515.2 (DI)
unnamed: LED515.4 (DO), LED516.2 (DI)
unnamed: LED516.4 (DO), LED517.2 (DI)
unnamed: LED517.4 (DO), LED518.2 (DI)
unnamed: LED518.4 (DO), LED519.2 (DI)
unnamed: LED519.4 (DO), LED520.2 (DI)
unnamed: LED521.4 (DO), LED522.2 (DI)
unnamed: LED522.4 (DO), LED523.2 (DI)
unnamed: LED523.4 (DO), LED524.2 (DI)
unnamed: LED524.4 (DO), LED525.2 (DI)
unnamed: LED525.4 (DO), LED526.2 (DI)
unnamed: LED526.4 (DO), LED527.2 (DI)
unnamed: LED527.4 (DO), LED528.2 (DI)
unnamed: LED528.4 (DO), LED529.2 (DI)
unnamed: LED529.4 (DO), LED530.2 (DI)
unnamed: LED531.4 (DO), LED532.2 (DI)
unnamed: LED532.4 (DO), LED533.2 (DI)
unnamed: LED533.4 (DO), LED534.2 (DI)
unnamed: LED534.4 (DO), LED535.2 (DI)
unnamed: LED535.4 (DO), LED536.2 (DI)
unnamed: LED536.4 (DO), LED537.2 (DI)
unnamed: LED537.4 (DO), LED538.2 (DI)
unnamed: LED538.4 (DO), LED539.2 (DI)
unnamed: LED539.4 (DO), LED540.2 (DI)
unnamed: LED541.4 (DO), LED542.2 (DI)
unnamed: LED542.4 (DO), LED543.2 (DI)
unnamed: LED543.4 (DO), LED544.2 (DI)
unnamed: LED544.4 (DO), LED545.2 (DI)
unnamed: LED545.4 (DO), LED546.2 (DI)
unnamed: LED546.4 (DO), LED547.2 (DI)
unnamed: LED547.4 (DO), LED548.2 (DI)
unnamed: LED548.4 (DO), LED549.2 (DI)
unnamed: LED549.4 (DO), LED550.2 (DI)
unnamed: LED551.4 (DO), LED552.2 (DI)
unnamed: LED552.4 (DO), LED553.2 (DI)
unnamed: LED553.4 (DO), LED554.2 (DI)
unnamed: LED554.4 (DO), LED555.2 (DI)
unnamed: LED555.4 (DO), LED556.2 (DI)
unnamed: LED556.4 (DO), LED557.2 (DI)
unnamed: LED557.4 (DO), LED558.2 (DI)
unnamed: LED558.4 (DO), LED559.2 (DI)
unnamed: LED559.4 (DO), LED560.2 (DI)
unnamed: LED561.4 (DO), LED562.2 (DI)
unnamed: LED562.4 (DO), LED563.2 (DI)
unnamed: LED563.4 (DO), LED564.2 (DI)
unnamed: LED564.4 (DO), LED565.2 (DI)
unnamed: LED565.4 (DO), LED566.2 (DI)
unnamed: LED566.4 (DO), LED567.2 (DI)
unnamed: LED567.4 (DO), LED568.2 (DI)
unnamed: LED568.4 (DO), LED569.2 (DI)
unnamed: LED569.4 (DO), LED_OUT1.1
ROW2: LED10.4 (DO), LED11.2 (DI)
ROW3: LED20.4 (DO), LED21.2 (DI)
ROW4: LED30.4 (DO), LED31.2 (DI)
ROW5: LED40.4 (DO), LED41.2 (DI)
ROW6: LED50.4 (DO), LED51.2 (DI)
ROW7: LED60.4 (DO), LED61.2 (DI)
ROW8: LED70.4 (DO), LED71.2 (DI)
ROW9: LED80.4 (DO), LED81.2 (DI)
ROW10: LED90.4 (DO), LED91.2 (DI)
ROW11: LED101.2 (DI), R1.2
ROW12: LED110.4 (DO), LED111.2 (DI)
ROW13: LED120.4 (DO), LED121.2 (DI)
ROW14: LED130.4 (DO), LED131.2 (DI)
ROW15: LED140.4 (DO), LED141.2 (DI)
ROW16: LED150.4 (DO), LED151.2 (DI)
ROW17: LED160.4 (DO), LED161.2 (DI)
ROW18: LED170.4 (DO), LED171.2 (DI)
ROW19: LED180.4 (DO), LED181.2 (DI)
ROW20: LED190.4 (DO), LED191.2 (DI)
ROW21: LED201.2 (DI), R3.2
ROW22: LED210.4 (DO), LED211.2 (DI)
ROW23: LED220.4 (DO), LED221.2 (DI)
ROW24: LED230.4 (DO), LED231.2 (DI)
ROW25: LED240.4 (DO), LED241.2 (DI)
ROW26: LED250.4 (DO), LED251.2 (DI)
ROW27: LED260.4 (DO), LED261.2 (DI)
ROW28: LED270.4 (DO), LED271.2 (DI)
ROW29: LED280.4 (DO), LED281.2 (DI)
ROW30: LED290.4 (DO), LED291.2 (DI)
ROW31: LED301.2 (DI), R4.2
ROW32: LED310.4 (DO), LED311.2 (DI)
ROW33: LED320.4 (DO), LED321.2 (DI)
ROW34: LED330.4 (DO), LED331.2 (DI)
ROW35: LED340.4 (DO), LED341.2 (DI)
ROW36: LED350.4 (DO), LED351.2 (DI)
ROW37: LED360.4 (DO), LED361.2 (DI)
ROW38: LED370.4 (DO), LED371.2 (DI)
ROW39: LED380.4 (DO), LED381.2 (DI)
ROW40: LED390.4 (DO), LED391.2 (DI)
ROW41: LED401.2 (DI), R5.2
ROW42: LED410.4 (DO), LED411.2 (DI)
ROW43: LED420.4 (DO), LED421.2 (DI)
ROW44: LED430.4 (DO), LED431.2 (DI)
ROW45: LED440.4 (DO), LED441.2 (DI)
ROW46: LED450.4 (DO), LED451.2 (DI)
ROW47: LED460.4 (DO), LED461.2 (DI)
ROW48: LED470.4 (DO), LED471.2 (DI)
ROW49: LED480.4 (DO), LED481.2 (DI)
ROW50: LED490.4 (DO), LED491.2 (DI)
ROW51: LED501.2 (DI), R6.2
ROW52: LED510.4 (DO), LED511.2 (DI)
ROW53: LED520.4 (DO), LED521.2 (DI)
ROW54: LED530.4 (DO), LED531.2 (DI)
ROW55: LED540.4 (DO), LED541.2 (DI)
ROW56: LED550.4 (DO), LED551.2 (DI)
ROW57: LED560.4 (DO), LED561.2 (DI)
